# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HARDWARE\RS485_Modbus;..\HARDWARE\WDG;..\HARDWARE\RTC;..\HARDWARE\SPI;..\HARDWARE\SD;..\MALLOC;..\FATFS\src;..\FATFS\exfuns
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart1.c stm32f10x_it.c led.c key.c 24c02.c w5500.c wizchip_conf.c socket.c dhcp.c spi.c dns.c W5500_APP.c eeprom_iic.c i2c.c SHT2X.c timer3.c usart4.c wifi.c usart2.c timer4.c BC28.c usart5.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SD/: MMC_SD.C spi2.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
